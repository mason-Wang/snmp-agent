# Keil uVision project enet_lwip.uvproj, settings and files
target snmp_lwip (ARM-ADS)
  device: LM3S6911 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: snmp_lwip +hex
  AfterMake: fromelf --bin --output .\rvmdk\snmp_lwip.bin .\rvmdk\snmp_lwip.axf
  c flags: Optim=3 oTime=1 wLevel=2
  c define: rvmdk PART_LM3S6911
  c include: .\app;.\inc;.\lwip-1.3.0\src\include;.\lwip-1.3.0\ports\stellaris\include;.\lwip-1.3.0\src\include\ipv4\;.\softeeprom
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: enet_lwip.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ./softeeprom/: softeeprom.c softeeprom_wrapper.c
    ./app/: command.c enet_lwip.c lwiplib.c uartstdio.c private_mib.c ustdlib.c
  group Libraries
    ./: driverlib.lib
  group Documentation
    ./: readme.txt
